# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: .\keil5_disp_size_bar.exe
  AfterMake: fromelf --bin --output .\Objects\Project.bin .\Objects\Project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: SYS_SUPPORT_OS,NDEBUG,HXTAL_VALUE=8000000
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\CMSIS;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Library;..\Library\SPI;..\Library\I2C;..\Library\USART;..\Hardware;..\Hardware\cst816;..\Hardware\st7789;..\Third_Party\SmartWatch_UI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Library
    ../Library/: EXTI.c TIMER.c
    ../Library/USART/: USART0.c USART.c
    ../Library/I2C/: I2C.c I2C0.c
  group Library/configs
    ../Library/I2C/: I2C_config.h
    ../Library/USART/: USART_config.h
    ../Library/: EXTI_config.h TIMER_config.h
  group Hardware
    ../Hardware/st7789/: st7789.c
    ../Hardware/cst816/: cst816t.c
    ../Hardware/: led.c
  group Doc
    ../Doc/: readme.txt
  group Third_Party/SmartWatch
    ../Third_Party/SmartWatch_UI/: ui.c ui_events.c ui_helpers.c ui_theme_manager.c ui_themes.c
    ../Third_Party/SmartWatch_UI/screens/: ui_Screen1.c ui_Screen2.c ui_Screen3.c ui_Screen4.c
    ../Third_Party/SmartWatch_UI/images/: ui_img_clockwise_hour_png.c ui_img_clockwise_min_png.c ui_img_clockwise_sec_png.c ui_img_logo_128_png.c ui_img_pin_png.c man.c
    ../Third_Party/SmartWatch_UI/components/: ui_comp_hook.c
software components: CMSIS:CORE 5.6.0, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:I2C 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:RTC 3.0.2, Device:StdPeripherals:SPI_I2S 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:USART 3.0.2, LVGL:lvgl:Essential 8.3.11, LVGL:lvgl:Extra Themes 8.3.11, LVGL:lvgl:Libs GIF 8.3.11, LVGL:lvgl:Porting 8.3.11
