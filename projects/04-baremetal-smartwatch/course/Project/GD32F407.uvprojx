# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  AfterMake: .\keil5_disp_size_bar.exe
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,NDEBUG
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\CMSIS;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Library;..\Library\SPI;..\Library\I2C;..\Library\USART;..\Hardware;..\Hardware\cst816;..\Hardware\st7789;..\Third_Party;..\Third_Party\lvgl;..\Third_Party\lv_drivers;..\Third_Party\SmartWatch_UI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_pmu.c gd32f4xx_rtc.c gd32f4xx_fwdgt.c gd32f4xx_wwdgt.c gd32f4xx_i2c.c gd32f4xx_spi.c
  group Library
    ../Library/: EXTI.c TIMER.c
    ../Library/USART/: USART0.c USART.c
    ../Library/I2C/: I2C.c I2C0.c
  group Library/configs
    ../Library/I2C/: I2C_config.h
    ../Library/USART/: USART_config.h
    ../Library/: EXTI_config.h TIMER_config.h
  group Hardware
    ../Hardware/st7789/: st7789.c
    ../Hardware/cst816/: cst816t.c
    ../Hardware/: bsp_basic_timer.h bsp_basic_timer.c led.c
  group Doc
    ../Doc/: readme.txt
  group Third_Party/lvgl
    ../Third_Party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Third_Party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Third_Party/lvgl/src/extra/: lv_extra.c
    ../Third_Party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_font_montserrat_14.c lv_font_montserrat_12.c
    ../Third_Party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Third_Party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Third_Party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Third_Party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Third_Party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Third_Party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Third_Party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Third_Party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Third_Party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Third_Party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Third_Party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Third_Party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Third_Party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Third_Party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Third_Party/lvgl/src/extra/widgets/led/: lv_led.c
    ../Third_Party/lvgl/src/extra/widgets/list/: lv_list.c
    ../Third_Party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Third_Party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Third_Party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Third_Party/lvgl/src/extra/widgets/span/: lv_span.c
    ../Third_Party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Third_Party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Third_Party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Third_Party/lvgl/src/extra/widgets/win/: lv_win.c
    ../Third_Party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
  group Third_Party/lv_drivers
    ../Third_Party/lv_drivers/: lv_port_disp.c lv_port_indev.c
    ../Third_Party/: lv_conf.h
  group Third_Party/SmartWatch
    ../Third_Party/SmartWatch_UI/: ui.c ui_events.c ui_helpers.c ui_theme_manager.c ui_themes.c
    ../Third_Party/SmartWatch_UI/screens/: ui_Screen1.c ui_Screen2.c ui_Screen3.c ui_Screen4.c
    ../Third_Party/SmartWatch_UI/images/: ui_img_clockwise_hour_png.c ui_img_clockwise_min_png.c ui_img_clockwise_sec_png.c ui_img_logo_128_png.c ui_img_pin_png.c man.c
    ../Third_Party/SmartWatch_UI/components/: ui_comp_hook.c
